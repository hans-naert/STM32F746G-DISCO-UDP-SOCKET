# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\stm32f746ng.sct
  link misc: --any_placement=first_fit
  group Source Files
    ./: main.c Blinky.c stdout_user.c UDP_Socket.c
  group Documentation
    ./: Abstract.txt
target Release (6210000::V6.21::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\stm32f746ng.sct
  link misc: --any_placement=first_fit --diag_suppress=L6314
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Buttons 1.1.1, Board Support:LED 1.1.1, CMSIS Driver:Ethernet MAC 1.12.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:USART 1.21.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.5, Network:CORE 7.19.0, Network:Interface:ETH 7.19.0, Network:Socket:BSD 7.19.0, Network:Socket:TCP 7.19.0, Network:Socket:UDP 7.19.0
